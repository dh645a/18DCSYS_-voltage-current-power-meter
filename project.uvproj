# Keil uVision project project.uvproj, settings and files
target Project (MCS-251)
  device: STC32G8K64 Series STC
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x117FF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: project +hex
  group Source
    ./Src/: main.c stc32_it.c SYSTEM.C
    ./base/: CONFIG.C
  group Middle
    ./middle/LCDapp/: lcd.c
    ./middle/Adjust/: Adjust.C
    ./middle/MENU/: multi_menu.c
    ./middle/WAVE/: WAVE.C
    ./middle/ALARM/: ALARM.C
    ./middle/FILTERING/: FILTERING.C
  group Base
    ./base/LCD/: lcd_init.c
    ./base/adc/: bsp_adc.c
    ./base/KEY/: base_key.c
    ./base/TIME/: TIME.c
    ./base/SPI/: spi.c
    ./base/PWM/: PWM.c
    ./base/BUZZER/: BUZZER.c
  group Doc
    ./: 功能说明.txt
  group DRIVE
    ./Driver/src/: STC32G_EEPROM.c
